# KOMPAS-3D part (DN200 НП ФИ PN25.m3d)

Model tree:
1. Операция без истории:1

Texts:
  DN200 НП ФИ PN25